SRC_URI += "file://adi_zynqmp_defconfig.cfg \
			file://user_2020-04-17-11-19-00.cfg \
            file://user_2020-04-20-17-12-00.cfg \
            file://user_2020-04-23-10-04-00.cfg \
            file://user_2020-04-23-10-13-00.cfg \
            file://user_2020-04-23-10-29-00.cfg \
            file://user_2020-04-23-10-44-00.cfg \
            file://user_2020-04-23-11-27-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

