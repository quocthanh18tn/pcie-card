FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
	file://system-user.dtsi \
	file://system-user-pcie-card.dtsi \
	"