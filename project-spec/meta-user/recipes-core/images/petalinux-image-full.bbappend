#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " pcieinit"
IMAGE_INSTALL_append = " pcietool"
IMAGE_INSTALL_append = " rrupy"
IMAGE_INSTALL_append = " librru"
IMAGE_INSTALL_append = " libiio"
